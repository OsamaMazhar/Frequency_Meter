# Keil uVision project Freqency Counter v1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Freqency Counter v1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Frequency Counter v1.c
